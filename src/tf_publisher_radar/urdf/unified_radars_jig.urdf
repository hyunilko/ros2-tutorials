Commit message: df

File: src/tf_publisher_radar/urdf/unified_radars_jig.urdf (robot description, URDF)
Before this commit: robot morning_car, 3 links, 2 joints
Joints:
- joint base_roof_lidar: origin xyz=0.716 -0.189 0 rpy=0 0 0 -> xyz=0 0 0 rpy=0 0 0
